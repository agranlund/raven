#include "hw/cpu.h"

#define VBR_PROXY_IN_ROM        1
#define PMMU_PAGESIZE           (4 * 1024UL)

extern NMIFunc_t   NMIFunc;
extern uint32_t    NMIBusy;

uint32_t*   vbrTable __attribute__((aligned(4)));
uint32_t*   mmuRootTable __attribute__((aligned(4)));
uint32_t*   mmuInvalidPtrTable __attribute__((aligned(4)));
uint32_t*   mmuInvalidPageTable __attribute__((aligned(4)));
uint32_t*   mmuInvalidPage __attribute__((aligned(4)));
uint32_t*   mmuInvalidPageDesc __attribute__((aligned(4)));


//-----------------------------------------------------------------------
// cpu
//-----------------------------------------------------------------------
void cpu_NullNMI(regs_t* r) {
}


bool cpu_Init()
{
    // set dummy nmi handler
    NMIFunc = cpu_NullNMI;
    NMIBusy = 0;

    uint32_t rev;
    cpu_Detect(&rev, 0);

    uint32_t pcr = 0;
    pcr |= (1 << 0);        // enable superscalar dispatch
    if ((rev == 1) || (rev == 5)) {
        pcr |= (1 << 5);    // disable store/load bypass (errata I14)
    }
    cpu_SetPCR(pcr);
    return true;
}


uint32_t cpu_Detect(uint32_t* revout, uint32_t* idout)
{
    uint32_t sku = CPU_UNKONWN;
    uint32_t rev = 1;

    uint32_t pcr = cpu_GetPCR();
    rev = (pcr >> 8) & 0xFF;
    if ((pcr & 0x000f0000) == 0)
        sku = CPU_68060;
    else if (rev == 4)
        sku = CPU_68LC060;
    else if (rev == 3)
        sku = CPU_68EC060;

    if (idout)
        *idout = pcr & 0xffffff00;

    if (revout)
        *revout = rev;

    return sku;
}


NMIFunc_t cpu_SetNMI(NMIFunc_t func)
{
    NMIFunc_t old = NMIFunc;
    NMIFunc = func;
    return old;
}


//-----------------------------------------------------------------------
// mmu
//-----------------------------------------------------------------------
uint32_t* mmu_Init(uint32_t unmapped_desc)
{
    mmuRootTable        = (uint32_t*) mem_LinearAlloc(128 * 4, 512);
    mmuInvalidPtrTable  = (uint32_t*) mem_LinearAlloc(128 * 4, 512);
    mmuInvalidPageTable = (uint32_t*) mem_LinearAlloc( 64 * 4, 256);
    mmuInvalidPageDesc  = (uint32_t*) mem_LinearAlloc(  1 * 4, 256);
    mmuInvalidPage      = (uint32_t*) mem_LinearAlloc(PMMU_PAGESIZE, PMMU_PAGESIZE);

    mmuInvalidPageDesc[0] = unmapped_desc ? unmapped_desc : (((uint32_t)mmuInvalidPage) | (PMMU_READWRITE | PMMU_CM_WRITETHROUGH));

    for (int i=0; i<PMMU_PAGESIZE/4; i++)
        mmuInvalidPage[i] = 0;

    for (int i=0; i<64; i++)
        mmuInvalidPageTable[i] = ((uint32_t)mmuInvalidPageDesc) | PMMU_INDIRECT;

    for (int i=0; i<128; i++)
        mmuInvalidPtrTable[i] = ((uint32_t)mmuInvalidPageTable) | PMMU_READWRITE;

    for (int i=0; i<128; i++)
        mmuRootTable[i] = ((uint32_t)mmuInvalidPtrTable) | PMMU_READWRITE;

    return mmuRootTable;
}


uint32_t* mmu_GetPageDescriptor(uint32_t log)
{
    const uint32_t ptrTableAddressMask = ~511UL;
    const uint32_t pageTableAddressMask = ~255UL;
    //const uint32_t pageAddressMask = ~(PMMU_PAGESIZE - 1);
    //uint32_t addr = log & ~(PMMU_PAGESIZE - 1);

    uint32_t rootIdx = (log >> 25) & 127;
    uint32_t ptrIdx  = (log >> 18) & 127;
    uint32_t pageIdx = (log >> 12) & 63;

    uint32_t* ptrTable = (uint32_t*) (mmuRootTable[rootIdx] & ptrTableAddressMask);
    if (ptrTable == mmuInvalidPtrTable) {
        ptrTable = (uint32_t*) mem_LinearAlloc(128 * 4, 512);
        for (int i=0; i<128; i++)
            ptrTable[i] = ((uint32_t)mmuInvalidPageTable) | PMMU_READWRITE;

        mmuRootTable[rootIdx] = ((uint32_t)ptrTable) | PMMU_READWRITE;
    }

    uint32_t* pageTable = (uint32_t*) (ptrTable[ptrIdx] & pageTableAddressMask);
    if (pageTable == mmuInvalidPageTable) {
        pageTable = (uint32_t*) mem_LinearAlloc(64 * 4, 256);
        for (int i=0; i<64; i++)
            pageTable[i] = ((uint32_t)mmuInvalidPageDesc) | PMMU_INDIRECT;
        ptrTable[ptrIdx] = ((uint32_t)pageTable) | PMMU_READWRITE;
    }

    return &pageTable[pageIdx];
}


void mmu_Map(uint32_t log, uint32_t phys, uint32_t size, uint32_t flags)
{
    const uint32_t pageAddressMask = ~(PMMU_PAGESIZE - 1);
    uint32_t end = (log + size + (PMMU_PAGESIZE - 1)) & pageAddressMask;
    uint32_t src = log & pageAddressMask;
    uint32_t dst = phys & pageAddressMask;

    while (src != end)
    {
        uint32_t* pageDescriptor = mmu_GetPageDescriptor(src);
        *pageDescriptor = flags | dst;
        src += PMMU_PAGESIZE;
        dst += PMMU_PAGESIZE;
    }
}


void mmu_Redirect(uint32_t logsrc, uint32_t logdst, uint32_t size)
{
    const uint32_t pageAddressMask = ~(PMMU_PAGESIZE - 1);
    uint32_t end = (logsrc + size + (PMMU_PAGESIZE - 1)) & pageAddressMask;
    uint32_t src = logsrc & pageAddressMask;
    uint32_t dst = logdst & pageAddressMask;

    while (src != end)
    {
        uint32_t* srcPageDescriptor = mmu_GetPageDescriptor(src);
        uint32_t* dstPageDescriptor = mmu_GetPageDescriptor(dst);
        *srcPageDescriptor = PMMU_INDIRECT | (uint32_t)dstPageDescriptor;
        src += PMMU_PAGESIZE;
        dst += PMMU_PAGESIZE;
    }
}

void mmu_Invalid(uint32_t log, uint32_t size)
{
    const uint32_t pageAddressMask = ~(PMMU_PAGESIZE - 1);
    uint32_t end = (log + size + (PMMU_PAGESIZE - 1)) & pageAddressMask;
    uint32_t src = log & pageAddressMask;

    while (src != end)
    {
        uint32_t* pageDescriptor = mmu_GetPageDescriptor(src);
        *pageDescriptor &= ~3UL;
        src += PMMU_PAGESIZE;
    }
}

// jmp ([0x08.w])  // 4ef0 01e1 0008
// jmp ([0x08.l])  // 4ef0 01f1 0000 0008

#if VBR_PROXY_IN_ROM
const uint16_t vbrProxy[] __attribute__((aligned(16))) = {
    0x4ef0, 0x01e1, 0x0000, 0x0000, 0x4ef0, 0x01e1, 0x0004, 0x0000, 0x4ef0, 0x01e1, 0x0008, 0x0000, 0x4ef0, 0x01e1, 0x000c, 0x0000,
    0x4ef0, 0x01e1, 0x0010, 0x0000, 0x4ef0, 0x01e1, 0x0014, 0x0000, 0x4ef0, 0x01e1, 0x0018, 0x0000, 0x4ef0, 0x01e1, 0x001c, 0x0000,
    0x4ef0, 0x01e1, 0x0020, 0x0000, 0x4ef0, 0x01e1, 0x0024, 0x0000, 0x4ef0, 0x01e1, 0x0028, 0x0000, 0x4ef0, 0x01e1, 0x002c, 0x0000,
    0x4ef0, 0x01e1, 0x0030, 0x0000, 0x4ef0, 0x01e1, 0x0034, 0x0000, 0x4ef0, 0x01e1, 0x0038, 0x0000, 0x4ef0, 0x01e1, 0x003c, 0x0000,
    0x4ef0, 0x01e1, 0x0040, 0x0000, 0x4ef0, 0x01e1, 0x0044, 0x0000, 0x4ef0, 0x01e1, 0x0048, 0x0000, 0x4ef0, 0x01e1, 0x004c, 0x0000,
    0x4ef0, 0x01e1, 0x0050, 0x0000, 0x4ef0, 0x01e1, 0x0054, 0x0000, 0x4ef0, 0x01e1, 0x0058, 0x0000, 0x4ef0, 0x01e1, 0x005c, 0x0000,
    0x4ef0, 0x01e1, 0x0060, 0x0000, 0x4ef0, 0x01e1, 0x0064, 0x0000, 0x4ef0, 0x01e1, 0x0068, 0x0000, 0x4ef0, 0x01e1, 0x006c, 0x0000,
    0x4ef0, 0x01e1, 0x0070, 0x0000, 0x4ef0, 0x01e1, 0x0074, 0x0000, 0x4ef0, 0x01e1, 0x0078, 0x0000, 0x4ef0, 0x01e1, 0x007c, 0x0000,
    0x4ef0, 0x01e1, 0x0080, 0x0000, 0x4ef0, 0x01e1, 0x0084, 0x0000, 0x4ef0, 0x01e1, 0x0088, 0x0000, 0x4ef0, 0x01e1, 0x008c, 0x0000,
    0x4ef0, 0x01e1, 0x0090, 0x0000, 0x4ef0, 0x01e1, 0x0094, 0x0000, 0x4ef0, 0x01e1, 0x0098, 0x0000, 0x4ef0, 0x01e1, 0x009c, 0x0000,
    0x4ef0, 0x01e1, 0x00a0, 0x0000, 0x4ef0, 0x01e1, 0x00a4, 0x0000, 0x4ef0, 0x01e1, 0x00a8, 0x0000, 0x4ef0, 0x01e1, 0x00ac, 0x0000,
    0x4ef0, 0x01e1, 0x00b0, 0x0000, 0x4ef0, 0x01e1, 0x00b4, 0x0000, 0x4ef0, 0x01e1, 0x00b8, 0x0000, 0x4ef0, 0x01e1, 0x00bc, 0x0000,
    0x4ef0, 0x01e1, 0x00c0, 0x0000, 0x4ef0, 0x01e1, 0x00c4, 0x0000, 0x4ef0, 0x01e1, 0x00c8, 0x0000, 0x4ef0, 0x01e1, 0x00cc, 0x0000,
    0x4ef0, 0x01e1, 0x00d0, 0x0000, 0x4ef0, 0x01e1, 0x00d4, 0x0000, 0x4ef0, 0x01e1, 0x00d8, 0x0000, 0x4ef0, 0x01e1, 0x00dc, 0x0000,
    0x4ef0, 0x01e1, 0x00e0, 0x0000, 0x4ef0, 0x01e1, 0x00e4, 0x0000, 0x4ef0, 0x01e1, 0x00e8, 0x0000, 0x4ef0, 0x01e1, 0x00ec, 0x0000,
    0x4ef0, 0x01e1, 0x00f0, 0x0000, 0x4ef0, 0x01e1, 0x00f4, 0x0000, 0x4ef0, 0x01e1, 0x00f8, 0x0000, 0x4ef0, 0x01e1, 0x00fc, 0x0000,
    0x4ef0, 0x01e1, 0x0100, 0x0000, 0x4ef0, 0x01e1, 0x0104, 0x0000, 0x4ef0, 0x01e1, 0x0108, 0x0000, 0x4ef0, 0x01e1, 0x010c, 0x0000,
    0x4ef0, 0x01e1, 0x0110, 0x0000, 0x4ef0, 0x01e1, 0x0114, 0x0000, 0x4ef0, 0x01e1, 0x0118, 0x0000, 0x4ef0, 0x01e1, 0x011c, 0x0000,
    0x4ef0, 0x01e1, 0x0120, 0x0000, 0x4ef0, 0x01e1, 0x0124, 0x0000, 0x4ef0, 0x01e1, 0x0128, 0x0000, 0x4ef0, 0x01e1, 0x012c, 0x0000,
    0x4ef0, 0x01e1, 0x0130, 0x0000, 0x4ef0, 0x01e1, 0x0134, 0x0000, 0x4ef0, 0x01e1, 0x0138, 0x0000, 0x4ef0, 0x01e1, 0x013c, 0x0000,
    0x4ef0, 0x01e1, 0x0140, 0x0000, 0x4ef0, 0x01e1, 0x0144, 0x0000, 0x4ef0, 0x01e1, 0x0148, 0x0000, 0x4ef0, 0x01e1, 0x014c, 0x0000,
    0x4ef0, 0x01e1, 0x0150, 0x0000, 0x4ef0, 0x01e1, 0x0154, 0x0000, 0x4ef0, 0x01e1, 0x0158, 0x0000, 0x4ef0, 0x01e1, 0x015c, 0x0000,
    0x4ef0, 0x01e1, 0x0160, 0x0000, 0x4ef0, 0x01e1, 0x0164, 0x0000, 0x4ef0, 0x01e1, 0x0168, 0x0000, 0x4ef0, 0x01e1, 0x016c, 0x0000,
    0x4ef0, 0x01e1, 0x0170, 0x0000, 0x4ef0, 0x01e1, 0x0174, 0x0000, 0x4ef0, 0x01e1, 0x0178, 0x0000, 0x4ef0, 0x01e1, 0x017c, 0x0000,
    0x4ef0, 0x01e1, 0x0180, 0x0000, 0x4ef0, 0x01e1, 0x0184, 0x0000, 0x4ef0, 0x01e1, 0x0188, 0x0000, 0x4ef0, 0x01e1, 0x018c, 0x0000,
    0x4ef0, 0x01e1, 0x0190, 0x0000, 0x4ef0, 0x01e1, 0x0194, 0x0000, 0x4ef0, 0x01e1, 0x0198, 0x0000, 0x4ef0, 0x01e1, 0x019c, 0x0000,
    0x4ef0, 0x01e1, 0x01a0, 0x0000, 0x4ef0, 0x01e1, 0x01a4, 0x0000, 0x4ef0, 0x01e1, 0x01a8, 0x0000, 0x4ef0, 0x01e1, 0x01ac, 0x0000,
    0x4ef0, 0x01e1, 0x01b0, 0x0000, 0x4ef0, 0x01e1, 0x01b4, 0x0000, 0x4ef0, 0x01e1, 0x01b8, 0x0000, 0x4ef0, 0x01e1, 0x01bc, 0x0000,
    0x4ef0, 0x01e1, 0x01c0, 0x0000, 0x4ef0, 0x01e1, 0x01c4, 0x0000, 0x4ef0, 0x01e1, 0x01c8, 0x0000, 0x4ef0, 0x01e1, 0x01cc, 0x0000,
    0x4ef0, 0x01e1, 0x01d0, 0x0000, 0x4ef0, 0x01e1, 0x01d4, 0x0000, 0x4ef0, 0x01e1, 0x01d8, 0x0000, 0x4ef0, 0x01e1, 0x01dc, 0x0000,
    0x4ef0, 0x01e1, 0x01e0, 0x0000, 0x4ef0, 0x01e1, 0x01e4, 0x0000, 0x4ef0, 0x01e1, 0x01e8, 0x0000, 0x4ef0, 0x01e1, 0x01ec, 0x0000,
    0x4ef0, 0x01e1, 0x01f0, 0x0000, 0x4ef0, 0x01e1, 0x01f4, 0x0000, 0x4ef0, 0x01e1, 0x01f8, 0x0000, 0x4ef0, 0x01e1, 0x01fc, 0x0000,
    0x4ef0, 0x01e1, 0x0200, 0x0000, 0x4ef0, 0x01e1, 0x0204, 0x0000, 0x4ef0, 0x01e1, 0x0208, 0x0000, 0x4ef0, 0x01e1, 0x020c, 0x0000,
    0x4ef0, 0x01e1, 0x0210, 0x0000, 0x4ef0, 0x01e1, 0x0214, 0x0000, 0x4ef0, 0x01e1, 0x0218, 0x0000, 0x4ef0, 0x01e1, 0x021c, 0x0000,
    0x4ef0, 0x01e1, 0x0220, 0x0000, 0x4ef0, 0x01e1, 0x0224, 0x0000, 0x4ef0, 0x01e1, 0x0228, 0x0000, 0x4ef0, 0x01e1, 0x022c, 0x0000,
    0x4ef0, 0x01e1, 0x0230, 0x0000, 0x4ef0, 0x01e1, 0x0234, 0x0000, 0x4ef0, 0x01e1, 0x0238, 0x0000, 0x4ef0, 0x01e1, 0x023c, 0x0000,
    0x4ef0, 0x01e1, 0x0240, 0x0000, 0x4ef0, 0x01e1, 0x0244, 0x0000, 0x4ef0, 0x01e1, 0x0248, 0x0000, 0x4ef0, 0x01e1, 0x024c, 0x0000,
    0x4ef0, 0x01e1, 0x0250, 0x0000, 0x4ef0, 0x01e1, 0x0254, 0x0000, 0x4ef0, 0x01e1, 0x0258, 0x0000, 0x4ef0, 0x01e1, 0x025c, 0x0000,
    0x4ef0, 0x01e1, 0x0260, 0x0000, 0x4ef0, 0x01e1, 0x0264, 0x0000, 0x4ef0, 0x01e1, 0x0268, 0x0000, 0x4ef0, 0x01e1, 0x026c, 0x0000,
    0x4ef0, 0x01e1, 0x0270, 0x0000, 0x4ef0, 0x01e1, 0x0274, 0x0000, 0x4ef0, 0x01e1, 0x0278, 0x0000, 0x4ef0, 0x01e1, 0x027c, 0x0000,
    0x4ef0, 0x01e1, 0x0280, 0x0000, 0x4ef0, 0x01e1, 0x0284, 0x0000, 0x4ef0, 0x01e1, 0x0288, 0x0000, 0x4ef0, 0x01e1, 0x028c, 0x0000,
    0x4ef0, 0x01e1, 0x0290, 0x0000, 0x4ef0, 0x01e1, 0x0294, 0x0000, 0x4ef0, 0x01e1, 0x0298, 0x0000, 0x4ef0, 0x01e1, 0x029c, 0x0000,
    0x4ef0, 0x01e1, 0x02a0, 0x0000, 0x4ef0, 0x01e1, 0x02a4, 0x0000, 0x4ef0, 0x01e1, 0x02a8, 0x0000, 0x4ef0, 0x01e1, 0x02ac, 0x0000,
    0x4ef0, 0x01e1, 0x02b0, 0x0000, 0x4ef0, 0x01e1, 0x02b4, 0x0000, 0x4ef0, 0x01e1, 0x02b8, 0x0000, 0x4ef0, 0x01e1, 0x02bc, 0x0000,
    0x4ef0, 0x01e1, 0x02c0, 0x0000, 0x4ef0, 0x01e1, 0x02c4, 0x0000, 0x4ef0, 0x01e1, 0x02c8, 0x0000, 0x4ef0, 0x01e1, 0x02cc, 0x0000,
    0x4ef0, 0x01e1, 0x02d0, 0x0000, 0x4ef0, 0x01e1, 0x02d4, 0x0000, 0x4ef0, 0x01e1, 0x02d8, 0x0000, 0x4ef0, 0x01e1, 0x02dc, 0x0000,
    0x4ef0, 0x01e1, 0x02e0, 0x0000, 0x4ef0, 0x01e1, 0x02e4, 0x0000, 0x4ef0, 0x01e1, 0x02e8, 0x0000, 0x4ef0, 0x01e1, 0x02ec, 0x0000,
    0x4ef0, 0x01e1, 0x02f0, 0x0000, 0x4ef0, 0x01e1, 0x02f4, 0x0000, 0x4ef0, 0x01e1, 0x02f8, 0x0000, 0x4ef0, 0x01e1, 0x02fc, 0x0000,
    0x4ef0, 0x01e1, 0x0300, 0x0000, 0x4ef0, 0x01e1, 0x0304, 0x0000, 0x4ef0, 0x01e1, 0x0308, 0x0000, 0x4ef0, 0x01e1, 0x030c, 0x0000,
    0x4ef0, 0x01e1, 0x0310, 0x0000, 0x4ef0, 0x01e1, 0x0314, 0x0000, 0x4ef0, 0x01e1, 0x0318, 0x0000, 0x4ef0, 0x01e1, 0x031c, 0x0000,
    0x4ef0, 0x01e1, 0x0320, 0x0000, 0x4ef0, 0x01e1, 0x0324, 0x0000, 0x4ef0, 0x01e1, 0x0328, 0x0000, 0x4ef0, 0x01e1, 0x032c, 0x0000,
    0x4ef0, 0x01e1, 0x0330, 0x0000, 0x4ef0, 0x01e1, 0x0334, 0x0000, 0x4ef0, 0x01e1, 0x0338, 0x0000, 0x4ef0, 0x01e1, 0x033c, 0x0000,
    0x4ef0, 0x01e1, 0x0340, 0x0000, 0x4ef0, 0x01e1, 0x0344, 0x0000, 0x4ef0, 0x01e1, 0x0348, 0x0000, 0x4ef0, 0x01e1, 0x034c, 0x0000,
    0x4ef0, 0x01e1, 0x0350, 0x0000, 0x4ef0, 0x01e1, 0x0354, 0x0000, 0x4ef0, 0x01e1, 0x0358, 0x0000, 0x4ef0, 0x01e1, 0x035c, 0x0000,
    0x4ef0, 0x01e1, 0x0360, 0x0000, 0x4ef0, 0x01e1, 0x0364, 0x0000, 0x4ef0, 0x01e1, 0x0368, 0x0000, 0x4ef0, 0x01e1, 0x036c, 0x0000,
    0x4ef0, 0x01e1, 0x0370, 0x0000, 0x4ef0, 0x01e1, 0x0374, 0x0000, 0x4ef0, 0x01e1, 0x0378, 0x0000, 0x4ef0, 0x01e1, 0x037c, 0x0000,
    0x4ef0, 0x01e1, 0x0380, 0x0000, 0x4ef0, 0x01e1, 0x0384, 0x0000, 0x4ef0, 0x01e1, 0x0388, 0x0000, 0x4ef0, 0x01e1, 0x038c, 0x0000,
    0x4ef0, 0x01e1, 0x0390, 0x0000, 0x4ef0, 0x01e1, 0x0394, 0x0000, 0x4ef0, 0x01e1, 0x0398, 0x0000, 0x4ef0, 0x01e1, 0x039c, 0x0000,
    0x4ef0, 0x01e1, 0x03a0, 0x0000, 0x4ef0, 0x01e1, 0x03a4, 0x0000, 0x4ef0, 0x01e1, 0x03a8, 0x0000, 0x4ef0, 0x01e1, 0x03ac, 0x0000,
    0x4ef0, 0x01e1, 0x03b0, 0x0000, 0x4ef0, 0x01e1, 0x03b4, 0x0000, 0x4ef0, 0x01e1, 0x03b8, 0x0000, 0x4ef0, 0x01e1, 0x03bc, 0x0000,
    0x4ef0, 0x01e1, 0x03c0, 0x0000, 0x4ef0, 0x01e1, 0x03c4, 0x0000, 0x4ef0, 0x01e1, 0x03c8, 0x0000, 0x4ef0, 0x01e1, 0x03cc, 0x0000,
    0x4ef0, 0x01e1, 0x03d0, 0x0000, 0x4ef0, 0x01e1, 0x03d4, 0x0000, 0x4ef0, 0x01e1, 0x03d8, 0x0000, 0x4ef0, 0x01e1, 0x03dc, 0x0000,
    0x4ef0, 0x01e1, 0x03e0, 0x0000, 0x4ef0, 0x01e1, 0x03e4, 0x0000, 0x4ef0, 0x01e1, 0x03e8, 0x0000, 0x4ef0, 0x01e1, 0x03ec, 0x0000,
    0x4ef0, 0x01e1, 0x03f0, 0x0000, 0x4ef0, 0x01e1, 0x03f4, 0x0000, 0x4ef0, 0x01e1, 0x03f8, 0x0000, 0x4ef0, 0x01e1, 0x03fc, 0x0000,
};
#else
static uint16_t* vbrProxy;
#endif

bool vbr_Init()
{
    vbrTable = (uint32_t*) mem_LinearAlloc(256 * 4, 256);
#if VBR_PROXY_IN_ROM
    for (uint32_t i=0; i<256*4; i+=4) {
        vbr_Set(i, (uint32_t) &vbrProxy[i]);
    }
#else
    vbrProxy = (uint16_t*) mem_LinearAlloc(256 * 4 * 2, 256);
    for (uint32_t i=0, j=0; i<256*4; i+=4) {
        vbrProxy[j++] = 0x4ef0; // jmp ([addr.w])
        vbrProxy[j++] = 0x01e1;
        vbrProxy[j++] = (uint16_t)i;
        vbrProxy[j++] = 0x0000; // unused
        vbr_Set(i, (uint32_t) &vbrProxy[j-4]);
    }
#endif
    vbr_Set(0x60, (uint32_t) vecRTE); // IRQ0 : Spurious
    vbr_Set(0x7C, (uint32_t) vecNMI); // IRQ7 : NMI
    vbr_Apply();
    return true;
}

void vbr_Set(uint32_t vec, uint32_t addr)
{
    vbrTable[vec >> 2] = addr;
}

void vbr_Apply()
{
    cpu_SetVBR((uint32_t)vbrTable);
}


//-----------------------------------------------------------------------
// motorola support package
//
//  Installed to vbr proxy by defaults.
//  can be reinstalled to different table later by calling msp_Install
//
//  eg, rvbios.prg can call msp_Install(0) to put them in TOS vectors
//  so that some programs (mint1.16) which use unimpl instructions
//  to identify cpu can do so correctly.
//
//-----------------------------------------------------------------------
extern void cpu_InstallSP(uint32_t vbr);

bool msp_ins;
uint32_t msp_vbr;
uint32_t msp_bak[10];

void msp_Backup(uint32_t vbr) {
    msp_bak[0] = *((uint32_t*)(vbr + 0xf4));
    msp_bak[1] = *((uint32_t*)(vbr + 0xd8));
    msp_bak[2] = *((uint32_t*)(vbr + 0xd0));
    msp_bak[3] = *((uint32_t*)(vbr + 0xd4));
    msp_bak[4] = *((uint32_t*)(vbr + 0xcc));
    msp_bak[5] = *((uint32_t*)(vbr + 0xc8));
    msp_bak[6] = *((uint32_t*)(vbr + 0xc4));
    msp_bak[7] = *((uint32_t*)(vbr + 0x2c));
    msp_bak[8] = *((uint32_t*)(vbr + 0xdc));
    msp_bak[9] = *((uint32_t*)(vbr + 0xf0));
}

void msp_Restore(uint32_t vbr) {
    *((uint32_t*)(vbr + 0xf4)) = msp_bak[0];
    *((uint32_t*)(vbr + 0xd8)) = msp_bak[1];
    *((uint32_t*)(vbr + 0xd0)) = msp_bak[2];
    *((uint32_t*)(vbr + 0xd4)) = msp_bak[3];
    *((uint32_t*)(vbr + 0xcc)) = msp_bak[4];
    *((uint32_t*)(vbr + 0xc8)) = msp_bak[5];
    *((uint32_t*)(vbr + 0xc4)) = msp_bak[6];
    *((uint32_t*)(vbr + 0x2c)) = msp_bak[7];
    *((uint32_t*)(vbr + 0xdc)) = msp_bak[8];
    *((uint32_t*)(vbr + 0xf0)) = msp_bak[9];
}

void msp_Install(uint32_t vbr) {
    if (msp_ins && (msp_vbr != vbr)) {
        msp_Restore(msp_vbr);
    }
    msp_Backup(vbr);
    cpu_InstallSP(vbr);
    vbr_Apply();
    msp_vbr = vbr;
    msp_ins = true;
}

bool msp_Init() {
    uint32_t vbr = cpu_GetVBR();
    if (vbr == 0) {
        return false;
    }
    msp_Install(vbr);
    return true;
}
